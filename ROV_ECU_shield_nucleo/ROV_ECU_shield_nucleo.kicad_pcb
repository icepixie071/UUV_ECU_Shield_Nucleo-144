# Repository icepixie071/UUV_ECU_Shield_Nucleo-144

## KiCad design ROV_ECU_shield_nucleo/ROV_ECU_shield_nucleo.kicad_pcb

Schematic: ROV_ECU_shield_nucleo.kicad_sch

Parts:
AC1: BNO085; Manufacturer_Part_Number BNO085
C1, C4, C50: 4.7u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2, C11: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C48: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C6, C7, C8, C9, C10, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C25, C26, C27, C28, C30, C31, C33, C34, C35, C37, C38, C39, C41, C42, C43, C44, C45, C46, C47, C49, C51, C52: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C24, C29: TBD; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C32, C36, C40: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C54, C55: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D11: D; D_SOD-323_HandSoldering; not fitted
D2, D3, D4, D5, D6, D7, D8, D10: D1213A-04S-7; SOT65P210X110-6N; Manufacturer_Part_Number D1213A-04S-7; Mouser Part Number 621-D1213A-04S-7
D9: KDZVTR27B; D_SOD-123F
F3: 20A; Fuseholder_Blade_Mini_Keystone_3568
IC1, IC2, IC3, IC4, IC5, IC6, IC9: DCL541A01; SOIC127P1000X265-16N; Manufacturer_Part_Number DCL541A01
IC7, IC8: ADUM3190TRQZ; SOP64P600X175-16N; Manufacturer_Part_Number ADUM3190TRQZ; Mouser Part Number 584-ADUM3190TRQZ
IC10: AP7375-33SA-7; SOT96P240X110-3N; Manufacturer_Part_Number AP7375-33SA-7; Mouser Part Number 621-AP7375-33SA-7
IC11, IC12, IC13: MPU-6500; QFN40P300X300X95-25N-D; Manufacturer_Part_Number MPU-6500; Mouser Part Number 410-MPU-6500
IC14: ATA6561-GAQW-N; SOIC127P600X175-8N; Manufacturer_Part_Number ATA6561-GAQW-N; Mouser Part Number 579-ATA6561-GAQW-N
IC15: AP7375-50SA-7; SOT96P240X110-3N; Manufacturer_Part_Number AP7375-33SA-7; Mouser Part Number 621-AP7375-33SA-7
J1: 24VPI; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J2: RS485_1; JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
J3: RS485_2; JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
J4: CAN; JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
J5: PWMO_1; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J6: GPIO_1; JST_ZH_B6B-ZR_1x06_P1.50mm_Vertical
J7: PWMO_2; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J8: PWMO_3; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J9: ISO_AN1; JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
J10: ISO_AN2; JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
J11: PWMO_4; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J12: PWMO_5; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J13: PWMO_6; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J14: PWMI_1; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J15: PWMI_2; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J16: NMOS_SW1; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J17: NMOS_SW2; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
J18: GPIO_2; JST_ZH_B6B-ZR_1x06_P1.50mm_Vertical
J19: UART; JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
J20: I2C; JST_ZH_B4B-ZR_1x04_P1.50mm_Vertical
J21: 3.3VPO; JST_ZH_B2B-ZR_1x02_P1.50mm_Vertical
JP1, JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 4.7u/1.6A; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
L2: L; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
PS1: MIWI06-24S05; MIWI06_S; Manufacturer_Part_Number MIWI06-24S05
Q1: FDS6898A; SOIC-8_3.9x4.9mm_P1.27mm
R1, R5, R9, R13: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4, R10, R12, R39, R41: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R11: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R7, R8, R14, R15, R16, R37, R38, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R18: 60; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36: TBD; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R40, R42: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R55: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R56: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
TP1, TP2: TestPoint; TestPoint_Pad_D1.0mm
U2, U3: MAX3485; SOIC-8_3.9x4.9mm_P1.27mm
U4: NUCLEOH723ZG; MODULE_NUCLEOH723ZG; PARTREV 2
Y1: 32.768k; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3.3VA: C21.1, C26.1, C44.1, IC7.1 (VDD1), IC8.1 (VDD1), L2.2, R27.2, R33.2
+3.3VP: C3.1, C5.1, C6.1, C8.1, C9.1, C12.1, C14.1, C16.1, C18.1, C20.1, C25.1, C30.1, C46.1, D1.2 (A), D2.5 (VP), D4.5 (VP), D5.5 (VP), D6.5 (VP), D7.5 (VP), D8.5 (VP), IC1.16 (VDD2), IC2.16 (VDD2), IC3.16 (VDD2), IC4.16 (VDD2), IC5.16 (VDD2), IC6.16 (VDD2), IC7.16 (VDD2), IC8.16 (VDD2), IC9.16 (VDD2), IC10.2 (VOUT), IC14.5 (VIO), J2.1, J3.1, J6.1, J9.1, J10.1, J18.1, J21.1, R1.1, R9.1, U2.8 (VCC), U3.8 (VCC)
+3V3: AC1.3 (VDD), AC1.28 (VDDIO), C7.1, C10.1, C13.1, C15.1, C17.1, C19.1, C31.1, C32.1, C33.1, C34.1, C36.1, C37.1, C38.1, C40.1, C41.1, C42.1, C49.1, C50.1, C52.1, D10.5 (VP), IC1.1 (VDD1), IC2.1 (VDD1), IC3.1 (VDD1), IC4.1 (VDD1), IC5.1 (VDD1), IC6.1 (VDD1), IC9.1 (VDD1), IC11.8 (VDDIO), IC11.13 (VDD), IC12.8 (VDDIO), IC12.13 (VDD), IC13.8 (VDDIO), IC13.13 (VDD), J19.1, J20.1, JP3.1 (A), R43.1, R44.1, R45.1, R53.1, R54.1, R55.1, R56.1, U4.CN8_7 (3V3_CN8)
+5V: C4.1, L1.2, U4.CN11_6 (5V_EXT)
+5VP: C47.1, C48.1, D3.5 (VP), D11.2 (A), IC14.3 (VCC), IC15.2 (VOUT), J4.1
+24V: C1.1, C2.1, C11.1, D1.1 (K), D9.1 (K), D11.1 (K), F3.2, IC10.1 (VIN), IC15.1 (VIN), J16.1, J17.1, PS1.22 (+VIN_1), PS1.23 (+VIN_2)
CANBUS_RX: D8.6 (CH4), IC6.11 (VI4), IC14.4 (RXD), J18.5
CANBUS_STBY: D8.3 (CH2), IC6.13 (VO2), IC14.8 (STBY), J18.3
CANBUS_TX: D8.4 (CH3), IC6.12 (VO3), IC14.1 (TXD), J18.4
GND: AC1.2 (GND_1), AC1.5 (PS1), AC1.6 (PS0/WAKE), AC1.25 (GND_2), C4.2, C7.2, C10.2, C13.2, C15.2, C17.2, C19.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C49.2, C50.2, C51.1, C52.2, C54.1, C55.1, D10.2 (VN), IC1.2 (GND1_1), IC1.8 (GND1_2), IC2.2 (GND1_1), IC2.8 (GND1_2), IC3.2 (GND1_1), IC3.8 (GND1_2), IC4.2 (GND1_1), IC4.8 (GND1_2), IC5.2 (GND1_1), IC5.8 (GND1_2), IC6.2 (GND1_1), IC6.8 (GND1_2), IC9.2 (GND1_1), IC9.8 (GND1_2), IC11.11 (FSYNC), IC11.18 (GND), IC11.20 (RESV_2), IC11.25 (T_PAD), IC12.11 (FSYNC), IC12.18 (GND), IC12.20 (RESV_2), IC12.25 (T_PAD), IC13.11 (FSYNC), IC13.18 (GND), IC13.20 (RESV_2), IC13.25 (T_PAD), J19.4, J20.4, JP3.3 (B), PS1.16 (-VOUT), R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, U4.CN3_1 (GND_CN3), U4.CN3_2 (GND_CN3__1), U4.CN4_1 (GND_CN4), U4.CN4_2 (GND_CN4__1), U4.CN7_8 (GND_CN7), U4.CN8_11 (GND_CN8), U4.CN8_13 (GND_CN8__1), U4.CN9_12 (GND_CN9), U4.CN9_23 (GND_CN9__1), U4.CN10_5 (GND_CN10), U4.CN10_17 (GND_CN10__1), U4.CN10_22 (GND_CN10__2), U4.CN10_27 (GND_CN10__3)
GNDA: C21.2, C23.1, C24.2, C26.2, C28.1, C29.2, C44.2, IC7.2 (GND1_1), IC7.8 (GND1_2), IC8.2 (GND1_1), IC8.8 (GND1_2), U4.CN10_3 (AGND_CN10)
GNDPWR: C1.2, C2.2, C3.2, C5.2, C6.2, C8.2, C9.2, C11.2, C12.2, C14.2, C16.2, C18.2, C20.2, C22.2, C25.2, C27.2, C30.2, C45.2, C46.2, C47.2, C48.2, D2.2 (VN), D3.2 (VN), D4.2 (VN), D5.2 (VN), D6.2 (VN), D7.2 (VN), D8.2 (VN), D9.2 (A), IC1.9 (GND2_1), IC1.15 (GND2_2), IC2.9 (GND2_1), IC2.15 (GND2_2), IC3.9 (GND2_1), IC3.15 (GND2_2), IC4.9 (GND2_1), IC4.15 (GND2_2), IC5.9 (GND2_1), IC5.15 (GND2_2), IC6.9 (GND2_1), IC6.15 (GND2_2), IC7.9 (GND2_1), IC7.15 (GND2_2), IC8.9 (GND2_1), IC8.15 (GND2_2), IC9.9 (GND2_1), IC9.15 (GND2_2), IC10.3 (GND), IC14.2 (GND), IC15.3 (GND), J1.2, J2.4, J3.4, J4.4, J5.2, J6.6, J7.2, J8.2, J9.4, J10.4, J11.2, J12.2, J13.2, J14.2, J15.2, J18.6, J21.2, JP1.1 (A), JP2.1 (A), PS1.2 (-VIN_1), PS1.3 (-VIN_2), Q1.1 (S1), Q1.3 (S2), R5.2, R6.2, R7.2, R8.2, R13.2, R14.2, R15.2, R16.2, R28.1, R34.1, R37.2, R38.2, R40.2, R42.2, U2.5 (GND), U3.5 (GND)
unnamed: AC1.4 (BOOTN), TP2.1 (1_1)
unnamed: AC1.9 (CAP), C51.2
unnamed: AC1.10 (CLKSEL0), R55.2, TP1.1 (1_1)
unnamed: AC1.17 (SA0/H_MOSI), JP3.2 (C)
unnamed: AC1.27 (XIN32), C54.2, Y1.1
unnamed: AC1.26 (XOUT32/CLKSEL1), C55.2, Y1.2
unnamed: C45.1, R17.1, R18.2
unnamed: D2.1 (CH1), J2.2, R2.2
unnamed: D2.3 (CH2), J2.3, R4.2
unnamed: D2.4 (CH3), J3.2, R10.2
unnamed: D2.6 (CH4), J3.3, R12.2
unnamed: D3.1 (CH1), IC14.7 (CANH), J4.3, R17.2
unnamed: D3.3 (CH2), IC14.6 (CANL), J4.2, R18.1
unnamed: D4.1 (CH1), J9.2, R25.1
unnamed: D4.3 (CH2), J9.3, JP1.2 (B), R26.1
unnamed: D4.4 (CH3), J10.2, R31.1
unnamed: D4.6 (CH4), J10.3, JP2.2 (B), R32.1
unnamed: D7.1 (CH1), IC4.14 (VO1), J6.2
unnamed: D7.3 (CH2), IC4.13 (VO2), J6.3
unnamed: D7.4 (CH3), IC4.12 (VO3), J6.4
unnamed: D7.6 (CH4), IC4.11 (VI4), J6.5
unnamed: D8.1 (CH1), IC6.14 (VO1), J18.2
unnamed: IC7.12 (+IN), R25.2, R28.2
unnamed: IC7.11 (-IN), R26.2, R29.1
unnamed: IC7.10 (COMP), R29.2
unnamed: IC7.6 (EAOUT2), R27.1
unnamed: IC7.7 (EAOUT), R30.1
unnamed: C23.2, IC7.3 (VREG1)
unnamed: C22.1, IC7.14 (VREG2)
unnamed: IC8.12 (+IN), R31.2, R34.2
unnamed: IC8.11 (-IN), R32.2, R35.1
unnamed: IC8.10 (COMP), R35.2
unnamed: IC8.6 (EAOUT2), R33.1
unnamed: IC8.7 (EAOUT), R36.1
unnamed: C28.2, IC8.3 (VREG1)
unnamed: C27.1, IC8.14 (VREG2)
unnamed: IC9.14 (VO1), R41.1
unnamed: IC9.13 (VO2), R39.1
unnamed: C35.1, IC11.10 (REGOUT)
unnamed: C39.1, IC12.10 (REGOUT)
unnamed: C43.1, IC13.10 (REGOUT)
unnamed: F3.1, J1.1
unnamed: J16.2, Q1.5 (D2), Q1.6 (D2)
unnamed: J17.2, Q1.7 (D1), Q1.8 (D1)
unnamed: L1.1, PS1.14 (+VOUT)
unnamed: Q1.2 (G1), R39.2, R40.1
unnamed: Q1.4 (G2), R41.2, R42.1
unnamed: R2.1, R3.2, R5.1, U2.6 (A)
unnamed: R1.2, R3.1, R4.1, U2.7 (B)
unnamed: R10.1, R11.2, R13.1, U3.6 (A)
unnamed: R9.2, R11.1, R12.1, U3.7 (B)
unnamed: L2.1, U4.CN10_1 (AVDD)
PA0/TIM2_CH1: IC5.3 (VI1), U4.CN10_29 (D32/TIMER_C_PWM1)
PA3/ADC1_INP15: C24.1, R30.2, U4.CN9_1 (A0/ADC12_INP15)
PA5/SPI1_SCK: IC11.23 (SCL/SCLK), U4.CN7_10 (D13/SPI_A_SCK)
PA6/SPI1_MISO: IC11.9 (SDO/AD0), U4.CN7_12 (D12/SPI_A_MISO)
PB3/SPI3_SCK: IC13.23 (SCL/SCLK), U4.CN7_15 (D23/I2S_B_CK/SPI_B_SCK)
PB4/SPI3_MISO: IC13.9 (SDO/AD0), U4.CN7_19 (D25/SPI_B_MISO)
PB5/SPI1_MOSI: IC11.24 (SDA/SDI), U4.CN7_14 (D11/SPI_A_MOSI/TIM_E_PWM1)
PB6/USART1_TX: IC1.3 (VI1), U4.CN10_14 (D1/USART_A_TX)
PB7/USART1_RX: IC1.6 (VO4), R52.1, U4.CN10_16 (D0/USART_A_RX)
PB8/I2C1_SCL: AC1.19 (H_SCL/SCK/RX), D10.3 (CH2), J20.3, R54.2, U4.CN7_2 (D15/I2C_A_SCL)
PB9/I2C1_SDA: AC1.20 (H_SDA/H_MISO/TX), D10.1 (CH1), J20.2, R53.2, U4.CN7_4 (D14/I2C_A_SDA)
PB10/TIM2_CH3: IC5.4 (VI2), U4.CN10_32 (D36/TIMER_C_PWM2)
PB11/TIM2_CH4: IC5.5 (VI3), U4.CN10_34 (D35/TIMER_C_PWM3)
PC0/ADC1_INP10: C29.1, R36.2, U4.CN9_3 (A1/ADC123_INP10)
PC2/SPI2_MISO: IC12.9 (SDO/AD0), U4.CN9_9 (A4/ADC123_INP12/I2C1_SDA)
PC3/SPI2_MOSI: IC12.24 (SDA/SDI), U4.CN9_5 (A2/ADC12_INP13)
PC6/USART6_TX: D10.4 (CH3), J19.2, U4.CN7_1 (D16/I2S_A_MCK)
PC7/USART6_RX: D10.6 (CH4), J19.3, R46.1, U4.CN7_11 (D21/I2S_B_MCK)
PC8/TIM3_CH3: IC9.3 (VI1), U4.CN8_2 (D43/SDMMC_D0)
PC9/TIM3_CH4: IC9.4 (VI2), U4.CN8_4 (D44/SDMMC_D1/I2S_A_CKIN)
PC12/SPI3_MOSI: IC13.24 (SDA/SDI), U4.CN8_10 (D47/SDMMC_CK)
PD0/D67/FDCAN1_RX: IC6.6 (VO4), R48.1, U4.CN9_25 (D67/CAN_RX)
PD1/D66/FDCAN1_TX: IC6.5 (VI3), U4.CN9_27 (D66/CAN_TX)
PD3/SPI2_SCK: IC12.23 (SCL/SCLK), U4.CN9_8 (D54/USART_B_RTS)
PD5/USART2_TX: IC2.3 (VI1), U4.CN9_6 (D53/USART_B_TX)
PD6/USART2_RX: IC2.6 (VO4), R51.1, U4.CN9_4 (D52/USART_B_RX)
PD14/TIM4_CH3: IC3.6 (VO4), R49.1, U4.CN7_16 (D10/SPI_A_CS/TIM_B_PWM3)
PD15/TIM4_CH4: IC5.6 (VO4), R50.1, U4.CN7_18 (D9/TIMER_B_PWM2)
PE6/TIM15_CH2: IC4.6 (VO4), R47.1, U4.CN10_28 (D38/TIMER_A_BKIN2)
PE7/D41: IC11.22 (NCS), R43.2, U4.CN10_20 (D41/TIMER_A_ETR)
PE8/D42: IC12.22 (NCS), R44.2, U4.CN10_18 (D42/TIMER_A_PWM1N)
PE9/TIM1_CH1: IC3.3 (VI1), U4.CN10_4 (D6/TIMER_A_PWM1)
PE11/TIM1_CH2: IC3.4 (VI2), U4.CN10_6 (D5/TIMER_A_PWM2)
PE12/D39: IC2.4 (VI2), U4.CN10_26 (D39/TIMER_A_PWM3N)
PE13/TIM1_CH3: IC3.5 (VI3), U4.CN10_10 (D3/TIMER_A_PWM3)
PE14/EXTI14: AC1.14 (H_INTN), U4.CN10_8 (D4/IO)
PE15/D37: IC1.4 (VI2), U4.CN10_30 (D37/TIMER_A_BKIN1)
PF3/TIM23_CH4: IC6.3 (VI1), U4.CN7_20 (D8/IO)
PF7/TIM23_CH2: IC4.4 (VI2), U4.CN9_26 (D62/SAI_B_MCLK)
PF9/TIM14_CH1: IC6.4 (VI2), U4.CN9_28 (D63/SAI_B_FS)
PG0/D65: U4.CN9_29 (D65/IO)
PG1/D64: U4.CN9_30 (D64/IO)
PG2/D49: IC13.22 (NCS), R45.2, U4.CN8_14 (D49/IO)
PG3/D50: U4.CN8_16 (D50/IO)
PG12/TIM23_CH1: IC4.3 (VI1), U4.CN10_2 (D7/IO)
PG14/TIM23_CH3: IC4.5 (VI3), U4.CN10_12 (D2/IO)
PWM_IN_1: D5.6 (CH4), IC3.11 (VI4), J14.1, R37.1
PWM_IN_2: D6.6 (CH4), IC5.11 (VI4), J15.1, R38.1
PWM_OUT_1: D5.1 (CH1), IC3.14 (VO1), J5.1
PWM_OUT_2: D5.3 (CH2), IC3.13 (VO2), J7.1
PWM_OUT_3: D5.4 (CH3), IC3.12 (VO3), J8.1
PWM_OUT_4: D6.1 (CH1), IC5.14 (VO1), J11.1
PWM_OUT_5: D6.3 (CH2), IC5.13 (VO2), J12.1
PWM_OUT_6: D6.4 (CH3), IC5.12 (VO3), J13.1
UART_BUS1_EN: IC1.13 (VO2), R7.1, U2.2 (~RE), U2.3 (DE)
UART_BUS1_RX: IC1.11 (VI4), R8.1, U2.1 (RO)
UART_BUS1_TX: IC1.14 (VO1), R6.1, U2.4 (DI)
UART_BUS2_EN: IC2.13 (VO2), R15.1, U3.2 (~RE), U3.3 (DE)
UART_BUS2_RX: IC2.11 (VI4), R16.1, U3.1 (RO)
UART_BUS2_TX: IC2.14 (VO1), R14.1, U3.4 (DI)
nRST: AC1.11 (NRST), R56.2, U4.CN8_5 (NRST_CN8)

Notes on the sheet:
FC-135 32.768000KHz 12.5 +20.0-20.0 (F)
絶縁ICを使ってみた(東京工業大学 ロボット技術研究会)
NOTE: --------------------------------- fc = foper/10 = (1/(2π)) * √(1/LC) --------------------------------- MIWI06 foper : 330kHz --------------------------------- https://edn.itmedia.co.jp/edn/articles/1809/25/news016.html ---------------------------------
スラスタ用PWM出力 x6 センサ用RS485バス x1 スラスタ用RS485バス x1 ライト制御用FET駆動 x2 センサ/RC制御用PWM入力 x2 汎用センサ用AN入力x 1 水圧センサ用AN入力x 1 その他デジタルGPI x その他デジタルGPO x
reserved:LD1
AP7375-**SA Vin_max=45V Iout_max=300mA
https://www.st.com/resource/en/schematic_pack/mb1364-h723zg-e01_schematic.pdf

Board: 4 copper layers, 70.0 x 139.4 mm, 166 parts (0 on the bottom side), 122 nets.
